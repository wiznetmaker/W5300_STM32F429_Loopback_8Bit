# Keil uVision project NUCLEO-F429ZI.uvprojx, settings and files
target NUCLEO-F429ZI (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: NUCLEO-F429ZI +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../../Libraries/ioLibrary_Driver/Application/loopback;../../../Libraries/ioLibrary_Driver/Ethernet;../../../Libraries/ioLibrary_Driver/Ethernet/W5300;../../../Port;../../../Port/ioLibrary_Driver/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Libraries/ioLibrary_Driver
    ../../../Libraries/ioLibrary_Driver/Ethernet/W5300/: w5300.c
    ../../../Libraries/ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ../../../Libraries/ioLibrary_Driver/Internet/DHCP/: dhcp.c
    ../../../Libraries/ioLibrary_Driver/Internet/DNS/: dns.c
    ../../../Libraries/ioLibrary_Driver/Internet/httpServer/: httpParser.c httpServer.c httpUtil.c
    ../../../Libraries/ioLibrary_Driver/Internet/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../../../Libraries/ioLibrary_Driver/Internet/MQTT/: mqtt_interface.c MQTTClient.c
    ../../../Libraries/ioLibrary_Driver/Internet/SNTP/: sntp.c
    ../../../Libraries/ioLibrary_Driver/Application/loopback/: loopback.c
  group Port/ioLibrary_Driver
    ../../../Port/ioLibrary_Driver/Src/: w5x00_bus.c w5x00_network.c
software components: CMSIS:CORE 4.3.0
